options:
  parameters:
    author: jonasj2001
    generate_options: qt_gui
    id: master
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '100'
  states: {}
- name: inp_amp
  id: variable
  parameters:
    value: mark/max_vco - vco_offset
  states: {}
- name: mark
  id: variable
  parameters:
    value: (max_vco+(spacing/t_symb))/2
  states: {}
- name: max_vco
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: space
  id: variable
  parameters:
    value: (max_vco-(spacing/t_symb))/2
  states: {}
- name: spacing
  id: variable
  parameters:
    value: '4'
  states: {}
- name: t_symb
  id: variable
  parameters:
    value: 1/960
  states: {}
- name: t_symb_ook
  id: variable
  parameters:
    value: 6/25
  states: {}
- name: vco_offset
  id: variable
  parameters:
    value: space/max_vco
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 127e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: vco_offset
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jonasj2001/Documents/aausat/lectures/best_studentspace/Workshop/master_host/message.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '150'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '62'
    type: float
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: t_symb_ook
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: inp_amp
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*t_symb)
    type: byte
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*t_symb_ook)
    minoutbuf: int(200e3)
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '0.999'
    samp_rate: samp_rate
    sensitivity: 2*math.pi*max_vco
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10240'
    srate: samp_rate/150
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '10240'
    srate: samp_rate/62
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '10240'
    srate: samp_rate/208
    type: float
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: 437.3e6
    gain: '70'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_sink_0_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: 437.3e6
    gain: '70'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 437.1e6
    gain0: '1'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:8000
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:8000
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:8001
    timeout: '100'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_c_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_char_to_float_0, '0', blocks_repeat_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', blocks_add_xx_0, '1']
- [blocks_float_to_complex_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', soapy_plutosdr_sink_0_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_keep_one_in_n_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_repeat_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_repeat_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_uchar_to_float_0, '0', blocks_keep_one_in_n_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_vco_c_0, '0', blocks_add_xx_0, '0']
- [blocks_vco_c_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_vco_c_0, '0', soapy_plutosdr_sink_0, '0']
- [zeromq_req_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [zeromq_req_source_0_0, '0', blocks_char_to_float_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_msgpair_to_var_0, inpair]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
