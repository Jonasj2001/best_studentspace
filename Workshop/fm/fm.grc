options:
  parameters:
    author: jonasj2001
    generate_options: qt_gui
    id: fm
    output_language: python
    title: fm
  states: {}

blocks:
- name: cut_off
  id: variable_qtgui_range
  parameters:
    start: '2000'
    step: '100'
    stop: '50000'
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: tran_width
  id: variable_qtgui_range
  parameters:
    start: '500'
    step: '50'
    stop: '10000'
    value: '2000'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    start: int(88.1e6)
    step: '5000'
    stop: int(108e6)
    value: int(98.1e6)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate//48e3)
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: tran_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Before filter"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"After filter"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Audio"'
    size: '10240'
    srate: samp_rate/20
    type: float
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    center_freq: tune
    gain: '-20'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_sdrplay_source_0, '0', low_pass_filter_0, '0']
- [soapy_sdrplay_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
